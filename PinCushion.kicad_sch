File: PinCushion.kicad_sch (KiCad schematic)
At the start: 5 parts

Commit message: Update PinCushion.kicad_sch
Connections:
- net at U3.27 (Non_Logic): now also U5.1 (Line); no longer U5.2 (Line)
